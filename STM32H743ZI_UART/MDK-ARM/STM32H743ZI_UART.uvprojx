# Keil uVision project STM32H743ZI_UART.uvprojx, settings and files
target STM32H743ZI_UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743ZI_UART +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c task_boot.c task_led.c task_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_flash.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_gpio.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
software components: CMSIS:CORE 4.1.0
